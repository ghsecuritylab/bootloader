# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: bootloader +hex
  AfterMake: ..\..\tool\after_build.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;           ../Drivers/STM32F1xx_HAL_Driver/Inc;           ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;           ../Drivers/CMSIS/Include;           ..\..\lib;        ../Middlewares/Third_Party/LwIP/src/include;        ../Middlewares/Third_Party/LwIP/system;        ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;        ../Middlewares/Third_Party/LwIP/src/include/lwip;        ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;        ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;        ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;        ../Middlewares/Third_Party/LwIP/src/include/netif;        ../Middlewares/Third_Party/LwIP/src/include/posix;        ../Middlewares/Third_Party/LwIP/src/include/posix/sys;        ../Middlewares/Third_Party/LwIP/system/arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c user_io.c user_flash.c user_boot.c user_uart.c spi_lcd.c user_spi.c delay.c spi_lcd_dma.c xmodem.c lwip.c ethernetif.c app_ethernet.c tftpserver.c flash_if.c udp_echoclient.c modbus_udp.c modbus_crc.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_eth.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chap-md5.c eap.c chap-new.c magic.c chap_ms.c lcp.c fsm.c upap.c mppe.c demand.c vj.c pppol2tp.c pppcrypt.c multilink.c ppp.c eui64.c ecp.c ccp.c pppoe.c auth.c utils.c ipv6cp.c pppapi.c pppos.c ipcp.c
    ../Middlewares/Third_Party/LwIP/src/core/: ip.c inet_chksum.c netif.c init.c sys.c tcp_in.c tcp_out.c memp.c def.c stats.c raw.c mem.c timeouts.c pbuf.c tcp.c udp.c dns.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c sockets.c netbuf.c netifapi.c tcpip.c api_msg.c err.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4_addr.c igmp.c ip4.c icmp.c etharp.c autoip.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c mld6.c ethip6.c inet6.c ip6.c ip6_addr.c icmp6.c nd6.c dhcp6.c
software components: CMSIS:CORE 4.1.0
